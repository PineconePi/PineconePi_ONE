<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimplADC0.ewp</path>
  </project>
  <batchBuild/>
</workspace>
