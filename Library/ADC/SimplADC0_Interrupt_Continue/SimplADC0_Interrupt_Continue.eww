<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimplADC0_Interrupt_Continue.ewp</path>
  </project>
  <batchBuild/>
</workspace>
