# Keil uVision project SWM320_SPIFlash.uvprojx, settings and files
target SWM320_SPIFlash (ARM-ADS)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.8.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SWM320_SPIFlash
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\BSP_Driv;..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\SWM320_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../CMSIS/DeviceSupport/: system_SWM320.c startup_SWM320.s
  group SWMLib
    ./: main.c
    ../SWM320_StdPeriph_Driver/: SWM320_gpio.c SWM320_port.c SWM320_spi.c SWM320_uart.c
  group BSP_Drive
    ../BSP_Driv/: bsp_SysTick.c bsp_UART.c bsp_SPIFlash.c
