# Keil uVision project RTX_CMSIS.uvprojx, settings and files
target SWM320 (ARM-ADS)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.7.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: RTX_CMSIS
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./APP/: main.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Driver:ADC 1.6.0, Device:Driver:GPIO 1.6.0, Device:Driver:PORT 1.6.0, Device:Driver:PWM 1.6.0, Device:Driver:Timer 1.6.0, Device:Driver:UART 1.6.0, Device:Startup 1.6.0
