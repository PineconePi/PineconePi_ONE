# Keil uVision project SWM320_StdPeriph_Driver.uvprojx, settings and files
target SWM320 (ARM-ADS)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.8.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SWM320_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c misc: --c99
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM320_StdPeriph_Driver/: SWM320_port.c SWM320_gpio.c SWM320_exti.c SWM320_timr.c SWM320_uart.c SWM320_adc.c SWM320_dma.c SWM320_i2c.c SWM320_pwm.c SWM320_can.c SWM320_spi.c SWM320_sdio.c SWM320_lcd.c SWM320_flash.c SWM320_crc.c SWM320_rtc.c SWM320_wdt.c SWM320_norflash.c SWM320_sdram.c SWM320_sram.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
