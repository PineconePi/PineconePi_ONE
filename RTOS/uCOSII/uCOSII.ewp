# IAR project uCOSII.ewp, settings and files
configuration SWM320 (ARM, debug)
  General.OGChipSelectEditMenu: SWM320xE Synwit SWM320xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver; .\APP\uCOSII; .\APP\uCOSII\Port; .\APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: uCOSII.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_i2c.c SWM320_flash.c SWM320_crc.c SWM320_sdio.c SWM320_can.c SWM320_uart.c SWM320_lcd.c SWM320_dma.c SWM320_timr.c SWM320_rtc.c SWM320_port.c SWM320_exti.c SWM320_pwm.c SWM320_spi.c SWM320_adc.c SWM320_gpio.c SWM320_wdt.c
  group CSL_CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM320.s
  group APP
    ./app/: main.c
  group uCOS_Port
    ./APP/uCOSII/Port/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group uCOS
    ./APP/uCOSII/: os_core.c os_flag.c os_mem.c os_task.c os_mutex.c os_sem.c os_q.c os_time.c os_mbox.c os_tmr.c
