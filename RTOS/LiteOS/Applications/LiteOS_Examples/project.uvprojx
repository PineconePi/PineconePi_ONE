# Keil uVision project project.uvprojx, settings and files
target SWM320_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.7.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ./App;./DeviceSupport;../../CMSIS/CoreSupport;../../CMSIS/DeviceSupport;../../Drivers;../../SWM320_StdPeriph_Driver;../../Middlewares/LiteOS/kernel/include;../../Middlewares/LiteOS/kernel/base/include;../../Middlewares/LiteOS/arch/arm/arm-m/include;./Configs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SWM320-LiteOS.sct
  group App
    ./App/: main.c example01.c example02.c example03.c example04.c example05.c example06.c example07.c example08.c example09.c example10.c example11.c example12.c example13.c example14.c example15.c
  group CMSIS
    ./DeviceSupport/: system_SWM320.c
    ../../CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group SWM320_StdPeriph_Driver
    ../../SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_can.c SWM320_crc.c SWM320_dma.c SWM320_exti.c SWM320_flash.c SWM320_gpio.c SWM320_i2c.c SWM320_lcd.c SWM320_norflash.c SWM320_port.c SWM320_pwm.c SWM320_rtc.c SWM320_sdio.c SWM320_sdram.c SWM320_spi.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c
  group Middleware/LiteOS/arch
    ../../Middlewares/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../Middlewares/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group Middleware/LiteOS/kernel
    ../../Middlewares/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../Middlewares/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../Middlewares/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
    ../../Middlewares/LiteOS/kernel/base/mem/common/: los_memstat.c los_slab.c los_slabmem.c
    ../../Middlewares/LiteOS/kernel/base/misc/: los_misc.c
    ../../Middlewares/LiteOS/kernel/base/om/: los_err.c
    ../../Middlewares/LiteOS/kernel/: los_init.c
