# Keil uVision project RT-Thread.uvprojx, settings and files
target SWM320 (ARM-ADS)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.5.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: RT-Thread
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./APP/: main.c
software components: CMSIS:CORE 3.40.0, Device:Driver:ADC 1.5.5, Device:Driver:GPIO 1.5.5, Device:Driver:PORT 1.5.5, Device:Driver:PWM 1.5.5, Device:Driver:Timer 1.5.5, Device:Driver:UART 1.5.5, Device:Startup 1.5.5, RTOS:kernel 3.0.3
